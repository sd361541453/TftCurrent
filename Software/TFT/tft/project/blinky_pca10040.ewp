# IAR project blinky_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; CONFIG_NFCT_PINS_AS_GPIOS
  ICCARM.CCIncludePath2: ..; ..\..\nRF5_SDK_15.2.0_9412b96\components; ..\..\nRF5_SDK_15.2.0_9412b96\components\boards; ..\..\nRF5_SDK_15.2.0_9412b96\components\drivers_nrf\nrf_soc_nosd; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\atomic; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\balloc; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\bsp; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\delay; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\experimental_section_vars; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\log; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\log\src; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\memobj; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\ringbuf; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\strerror; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\util; ..\..\nRF5_SDK_15.2.0_9412b96\components\toolchain\cmsis\include; ..\..\nRF5_SDK_15.2.0_9412b96\external\fprintf; ..\..\nRF5_SDK_15.2.0_9412b96\integration\nrfx; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx\hal; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx\mdk; ..\..\nRF5_SDK_15.2.0_9412b96\integration\nrfx\legacy; D:\Work\通用电源\TFT 电流表\Software\TFT\nRF5_SDK_15.2.0_9412b96\modules\nrfx\drivers\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  AARM.AUserIncludes: ..\..\..\config; ..\..\nRF5_SDK_15.2.0_9412b96\components; ..\..\nRF5_SDK_15.2.0_9412b96\components\boards; ..\..\nRF5_SDK_15.2.0_9412b96\components\drivers_nrf\nrf_soc_nosd; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\atomic; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\balloc; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\bsp; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\delay; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\experimental_section_vars; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\log; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\log\src; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\memobj; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\ringbuf; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\strerror; ..\..\nRF5_SDK_15.2.0_9412b96\components\libraries\util; ..\..\nRF5_SDK_15.2.0_9412b96\components\toolchain\cmsis\include; ..\..\..; ..\..\nRF5_SDK_15.2.0_9412b96\external\fprintf; ..\..\nRF5_SDK_15.2.0_9412b96\integration\nrfx; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx\hal; ..\..\nRF5_SDK_15.2.0_9412b96\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: blinky_pca10040.hex
  ILINK.IlinkOutputFile: blinky_pca10040.out
  ILINK.IlinkIcfFile: blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: lcd.c main.c
    ../../nRF5_SDK_15.2.0_9412b96/integration/nrfx/legacy/: nrf_drv_spi.c
    ../../nRF5_SDK_15.2.0_9412b96/modules/nrfx/drivers/src/: nrfx_spi.c nrfx_spim.c
    ../config/: sdk_config.h
  group None
    ../../nRF5_SDK_15.2.0_9412b96/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Libraries
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/atomic/: nrf_atomic.c
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/balloc/: nrf_balloc.c
    ../../nRF5_SDK_15.2.0_9412b96/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/memobj/: nrf_memobj.c
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../nRF5_SDK_15.2.0_9412b96/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
